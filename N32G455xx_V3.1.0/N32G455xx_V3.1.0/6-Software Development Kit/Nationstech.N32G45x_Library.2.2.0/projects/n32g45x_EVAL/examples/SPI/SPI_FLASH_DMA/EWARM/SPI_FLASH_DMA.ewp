# IAR project SPI_FLASH_DMA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G457QE Nations N32G457QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G45X; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\bsp\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_FLASH_DMA.bin
  ILINK.IlinkOutputFile: SPI_FLASH_DMA.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_dma.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_spi.c n32g45x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x_EWARM.s
  group USER
    ../../../../bsp/src/: delay.c log.c
    ../src/: main.c n32g45x_it.c spi_flash.c
