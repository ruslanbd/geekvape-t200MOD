# Keil uVision project CAN_Tx_Rx.uvprojx, settings and files
target N32G45x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN_Transmit_Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_can.c n32g45x_dbg.c n32g45x_flash.c n32g45x_gpio.c n32g45x_pwr.c n32g45x_usart.c n32g45x_bkp.c n32g45x_rcc.c n32g45x_rtc.c
  group USER
    ../src/: main.c User_Can_Config.c User_LED_Config.c User_Systick_Config.c User_Usart_Config.c n32g45x_it.c
  group DOC
    ../: readme.txt
