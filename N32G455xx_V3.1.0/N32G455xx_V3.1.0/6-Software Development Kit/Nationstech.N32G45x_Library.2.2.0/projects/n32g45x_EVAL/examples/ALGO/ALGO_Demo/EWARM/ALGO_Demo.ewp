# IAR project ALGO_Demo.ewp, settings and files
configuration N32G45x (ARM, debug)
  General.OGChipSelectEditMenu: N32G457QE Nations N32G457QE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G45X; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; __IAR_ARM
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32g45x_std_periph_driver/inc; ../../../../bsp/inc; ../../../../../../firmware/n32g45x_algo_lib/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALGO_Demo.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32g45x_algo_lib\lib\n32g45x_aes.lib; ..\..\..\..\..\..\firmware\n32g45x_algo_lib\lib\n32g45x_algo_common.lib; ..\..\..\..\..\..\firmware\n32g45x_algo_lib\lib\n32g45x_des.lib; ..\..\..\..\..\..\firmware\n32g45x_algo_lib\lib\n32g45x_hash.lib; ..\..\..\..\..\..\firmware\n32g45x_algo_lib\lib\n32g45x_rng.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ALGO
    ../../../../../../firmware/n32g45x_algo_lib/lib/: n32g45x_aes.lib n32g45x_algo_common.lib n32g45x_des.lib n32g45x_hash.lib n32g45x_rng.lib
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x_EWARM.s
  group USER
    ../src/: main.c n32g45x_it.c
