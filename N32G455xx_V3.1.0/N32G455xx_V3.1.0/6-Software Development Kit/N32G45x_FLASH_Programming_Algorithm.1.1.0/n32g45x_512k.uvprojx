# Keil uVision project n32g45x_512k.uvprojx, settings and files
target N32G45x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: N32G45x
  AfterMake: cmd /c copy /Y .\Objects\N32G45x.axf ..\N32G45x.FLM
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MEM
  c include: src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\src\Target.lin
  link misc: --diag_suppress L6305
  group src
    ./src/: FlashDev.c FlashPrg.c
