# Keil uVision project JumpToBoot.uvprojx, settings and files
target N32G45x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JumpToBoot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32g45x_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group Driver
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: n32g45x_flash.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_rcc.c n32g45x_usart.c
  group User
    ../src/: main.c n32g45x_it.c
  group Bsp
    ../src/: bsp_usart.c
  group DOC
    ../: readme.txt
