# IAR project JumpToBoot.ewp, settings and files
configuration N32G45x (ARM, debug)
  General.OGChipSelectEditMenu: N32G457QE Nations N32G457QE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G45X; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/n32g45x_std_periph_driver/inc; ../../../../../../firmware/CMSIS/device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JumpToBoot.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Bsp
    ../src/: bsp_usart.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g45x.c
  group DOC
    ../: readme.txt
  group Driver
    ../../../../../../firmware/n32g45x_std_periph_driver/src/: n32g45x_flash.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_rcc.c n32g45x_usart.c
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g45x_EWARM.s
  group User
    ../src/: main.c n32g45x_it.c
