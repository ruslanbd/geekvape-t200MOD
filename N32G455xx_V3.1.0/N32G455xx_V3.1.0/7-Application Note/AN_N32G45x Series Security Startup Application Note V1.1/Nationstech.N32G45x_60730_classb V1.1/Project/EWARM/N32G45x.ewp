# IAR project N32G45x.ewp, settings and files
configuration N32G45x (ARM, debug)
  General.OGChipSelectEditMenu: N32G457VE Nations N32G457VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: N32G45X; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\Nations\N32G45x\Include; ..\..\Drivers\n32g45x_std_periph_driver\inc; ..\..\Middlewares\N32_SelfTest_Library\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N32G45x.hex
  ILINK.IlinkOutputFile: N32G45x.out
  ILINK.IlinkIcfFile: N32G45x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/Nations/N32G45x/Source/Templates/iar/: startup_n32g45x_EWARM.s
  group Application/User
    ../: main.c n32g45x_it.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/Nations/N32G45x/Source/Templates/: system_n32g45x.c
  group Drivers/N32_SelfTest_Code
    ./: n32g45x_STLcpurunIAR.s n32g45x_STLcpustartIAR.s n32g45x_STLRamMcMxIAR.s
  group Drivers/N32_SelfTest_Library
    ../../Middlewares/N32_SelfTest_Library/src/: n32g45x_STLclockrun.c n32g45x_STLclockstart.c n32g45x_STLcrc32Run.c n32g45x_STLmain.c n32g45x_STLstartup.c n32g45x_STLtranspRam.c
  group Drivers/N32G45x_Periph
    ../../Drivers/n32g45x_std_periph_driver/src/: misc.c n32g45x_bkp.c n32g45x_crc.c n32g45x_dbg.c n32g45x_flash.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_tim.c n32g45x_usart.c n32g45x_wwdg.c
