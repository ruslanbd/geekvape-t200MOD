# Keil uVision project N32G45x.uvprojx, settings and files
target N32G45x (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G45x_SelfTest +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: srecord_crc32.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: N32G45x,USE_STDPERIPH_DRIVER
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\n32g45x_std_periph_driver\inc;..\..\Drivers\CMSIS\Device\Nations\N32G45x\Include;..\..\Middlewares\N32_SelfTest_Library\inc;..\..\Project
  asm define: ARTISAN=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\N32G45x_SelfTest.sct
  group User
    ../: main.c n32g45x_it.c CRC32_fast_static_lut.c
  group CMSIS
    ../../Drivers/CMSIS/Device/Nations/N32G45x/Source/Templates/: system_n32g45x.c
    ../../Drivers/CMSIS/Device/Nations/N32G45x/Source/Templates/keil/: startup_n32g45x.s
  group N32_SelfTest_Code
    ./: n32g45x_STLcpurunKEIL.s n32g45x_STLcpustartKEIL.s n32g45x_STLRamMcMxKEIL.s
  group N32_SelfTest_Library
    ../../Middlewares/N32_SelfTest_Library/src/: n32g45x_STLclockrun.c n32g45x_STLclockstart.c n32g45x_STLcrc32Run.c n32g45x_STLmain.c n32g45x_STLstartup.c n32g45x_STLtranspRam.c
  group N32G45x_Periph
    ../../Drivers/n32g45x_std_periph_driver/src/: misc.c n32g45x_bkp.c n32g45x_crc.c n32g45x_dbg.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_tim.c n32g45x_usart.c n32g45x_wwdg.c
